<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8S103F3P6_CPP.ewp</path>
    </project>
    <batchBuild />
</workspace>
