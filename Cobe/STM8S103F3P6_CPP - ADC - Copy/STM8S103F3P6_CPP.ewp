# IAR project STM8S103F3P6_CPP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; system; drivers\gpio; drivers\i2c; drivers\adc; drivers\reg; tests\i2c; utils\queue; tests\gpio; tests; utils\CmdSvr; utils\CmdSvr\I2C_CMD; drivers\SPI; drivers\interrupt; tests\Spi; tests\adc; utils\RTF; drivers\eeprom; drivers\timers; drivers\IR; drivers\watchdog; drivers\optional_bytes
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8S103F3P6_CPP.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group App
    app/: main.c
  group drivers/adc
    drivers/adc/: adc.h
  group drivers/eeprom
    drivers/eeprom/: eeprom.c
  group drivers/gpio
    drivers/gpio/: DigitalIn.h DigitalOut.h
  group drivers/Interrupt
    drivers/interrupt/: interrupt.h
  group drivers/IR
    drivers/IR/: IrDecoder.h IrEncoder.h
  group drivers/optional_bytes
    drivers/optional_bytes/: optional_bytes.h
  group drivers/reg
    drivers/reg/: reg_t.h
  group drivers/timers
    drivers/timers/: gpt1.h gpt2.h gpt4.h pulseIn1.h pulseIn2.h pulseOut1.h pulseOut2.h
  group drivers/watchdog
    drivers/watchdog/: IWDG.c
  group std_peripheral_lib
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_i2c.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c
  group system
    system/: stm8s_it.c system.c
  group tests
    tests/adc/: adc_tests.c
    tests/gpio/: gpio_tests.c
    tests/: templates.h timers_test.cpp timers_test.h
  group utils/CmdSvr
    utils/CmdSvr/: CmdSvr.c
    utils/CmdSvr/I2C_CMD/: I2C_Commands.c
  group utils/queue
    utils/queue/: queue.h
  group utils/RTF
    utils/RTF/: RTF.c
