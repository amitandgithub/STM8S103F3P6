# IAR project STM8S103F3P6_CPP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: App\common; App\PowerMonitor; STM8S_StdPeriph_Driver\inc; system; HAL\adc; HAL\common; HAL\eeprom; HAL\gpio; HAL\i2c; HAL\interrupt; HAL\optional_bytes; HAL\spi; HAL\timers; HAL\uart; HAL\watchdog; utils\queue; Devices\common; Devices\Rotary Encoder; Devices\eeprom\AT24Cxx; Devices\Oled; Devices\INA219; Devices\IR; platform\SoftwareTimers; utils\common; tests; tests\gpio; tests\i2c; tests\timers; tests\SoftwareTimers
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8S103F3P6_CPP.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group App
    app/: main.c
  group App/common
    app/common/: App.h
  group App/PowerMonitor
    app/PowerMonitor/: PowerMonitor.h
  group Devices/common
    Devices/common/: Devices.h
  group Devices/eeprom/AT24Cxx
    Devices/eeprom/AT24Cxx/: AT24Cxx.h
  group Devices/INA219
    Devices/INA219/: INA219.h
  group Devices/IR
    Devices/IR/: IrDecoder.h IrDecoder1.h IrDecoder2.h IrEncoder.h IrEncoder1.h IrEncoder2.h TvCodes.h
  group Devices/Oled
    Devices/Oled/: fonts.c SD1306.h
  group Devices/Rotary Encoder
    Devices/Rotary Encoder/: RotaryEncoder.h
  group HAL/common
    HAL/common/: HAL.h HAL_Objects.cpp HAL_Objects.h serial.h
  group HAL/gpio
    HAL/gpio/: Gpio.h GpioIn.h GpioOut.h
  group HAL/i2c
    HAL/i2c/: i2c.h i2c_common.h i2cMasterIntr.h i2cPoll.h
  group HAL/timers
    HAL/timers/: gpt1.h gpt2.h gpt4.h pulseIn1.h pulseIn2.h pulseOut1.h pulseOut2.h
  group platform/SoftwareTimers
    platform/SoftwareTimers/: SoftwareTimers.h
  group std_peripheral_lib
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_i2c.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c
  group system
    system/: stm8s_it.c system.c
  group tests/gpio
    tests/gpio/: gpio_tests.c
  group tests/i2c
    tests/i2c/: i2c_tests.h
  group tests/SoftwareTimers
    tests/SoftwareTimers/: SoftwareTimers_Tests.h
  group tests/templates
    tests/: templates.h
  group tests/timers
    tests/timers/: timers_test.cpp timers_test.h
  group utils/common
    utils/common/: Utils.h
  group utils/queue
    utils/queue/: queue.h queueBase.h queueG.h
  group utils/RTF
    utils/RTF/: RTF.c
