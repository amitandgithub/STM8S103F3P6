# IAR project STM8S103F3P6_CPP.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; system; HAL\adc; HAL\common; HAL\eeprom; HAL\gpio; HAL\i2c; HAL\interrupt; HAL\optional_bytes; HAL\spi; HAL\timers; HAL\uart; HAL\watchdog; HW_Modules\Rotary Encoder; tests; tests\gpio
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8S103F3P6_CPP.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group App
    app/: main.c
  group HAL/gpio
    HAL/gpio/: Gpio.h GpioIn.h GpioOut.h
  group HW_Modules/Rotary Encoder
    HW_Modules/Rotary Encoder/: RotaryEncoder.h
  group std_peripheral_lib
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_i2c.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c
  group system
    system/: stm8s_it.c system.c
  group tests/gpio
    tests/gpio/: gpio_tests.c
  group utils/queue
    utils/queue/: queue.h
  group utils/RTF
    utils/RTF/: RTF.c
